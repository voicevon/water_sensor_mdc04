# Keil uVision project FID_0.uvproj, settings and files
target FID_0 (MCS-51)
  device: R8051XC2 CAST, Inc.
  cpu: IRAM(0-0xFF) CLOCK(24000000)  MOD517DP MDU_R515
  output: ca51f003 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\DEVICE\inc;..\DRIVE\inc
  link misc: REMOVEUNUSED
  group USER
    ./: main.c
  group DRIVE
    ../DRIVE/src/: delay.c uart.c IIC.c MDC04_IIC.c
  group DEVICE
    ../DEVICE/src/: system_clock.c
  group STARUP
    ../DEVICE/: STARTUP.A51
