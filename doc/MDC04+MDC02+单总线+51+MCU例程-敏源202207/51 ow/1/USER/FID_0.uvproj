# Keil uVision project FID_0.uvproj, settings and files
target FID_0 (MCS-51)
  device: C8051 Core CAST, Inc.
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: ca51f003 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\DEVICE\inc;..\DRIVE\inc
  link misc: REMOVEUNUSED
  group USER
    ./: main.c
  group DRIVE
    ../DRIVE/src/: delay.c uart.c MDC04.c owmy.c
  group DEVICE
    ../DEVICE/src/: system_clock.c
  group STARUP
    ../DEVICE/: STARTUP.A51
